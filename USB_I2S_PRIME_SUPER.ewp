# IAR project USB_I2S_PRIME_SUPER.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RC ST STM32F446RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F446xx; USE_USB_FS; USE_USB_AUDIO_PLAYBACK
  ICCARM.CCIncludePath2: Audio\Inc; STM32_USB_Device_Library\Class\AUDIO_10\Inc; STM32_USB_Device_Library\Core\Inc; STM32F4xx_HAL_Driver\Inc; User\Inc; STM32_USB_Device_Library\Class\HID\inc; STM32_USB_Device_Library\Class\CustomHID\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_I2S_PRIME_SUPER.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f446_flash_Playback.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Audio
    Audio/Src/: audio_usb_nodes.c audio_usb_playback_session.c usbd_audio_if.c
  group STM32_USB_Device_Library/Class/Audio
    STM32_USB_Device_Library/Class/AUDIO_10/Src/: usbd_audio.c
  group STM32_USB_Device_Library/Class/CustomHID
    STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group STM32_USB_Device_Library/Core
    STM32_USB_Device_Library/Core/Src/: usbd_core_ex.c usbd_ctlreq.c usbd_ioreq.c
  group STM32F4xx_HAL_Driver
    STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group System
    User/Src/: startup_stm32f446xx.s system_stm32f4xx.c
  group User
    User/Src/: audio_configuration.c audio_speaker_node.c ConfigurationMode.c Delay.c DSP.c Events.c I2C.c I2C_Memory.c main.c SAI.c SoundCardMode.c stm32f4xx_it.c usb_audio_descriptors.c usbd_conf.c usbd_desc.c USBDevice.c
